# Keil uVision project KL27Chainsaw.uvprojx, settings and files
target MKL27Z64xxx4 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL27Z64xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KL27Chainsaw
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --library_interface=armcc --library_type=microlib --c99 --diag_suppress=1296,186 -DFSL_OSA_BM_TIMER_CONFIG=2 -DCPU_MKL27Z64VLH4 -DKEIL
  c include: ".\SDK\platform\hal\inc";".\SDK\platform\hal\src\sim\MKL27Z644";".\SDK\platform\system\src\clock\MKL27Z644";".\SDK\platform\system\inc";".\SDK\platform\osa\inc";".\SDK\platform\drivers\inc";".\SDK\platform\CMSIS\Include";".\SDK\platform\devices";".\SDK\platform\devices\MKL27Z644\include";".\SDK\platform\utilities\src";".\SDK\platform\utilities\inc";".\SDK\platform\devices\MKL27Z644\startup";".\Generated_Code\SDK\platform\devices\MKL27Z644\startup";".\Static_Code\IO_Map";".\Static_Code\Peripherals";".\Sources";".\Generated_Code";".\Generated_Code";".\SDK\platform\devices\MKL27Z644\startup";".\SDK\platform\devices";".\SDK\platform\drivers\src\adc16";".\SDK\platform\drivers\src\gpio";".\SDK\platform\drivers\src\rtc";".\SDK\platform\drivers\src\tpm";".\SDK\platform\hal\src\adc16";".\SDK\platform\hal\src\gpio";".\SDK\platform\hal\src\lpuart";".\SDK\platform\hal\src\mcglite";".\SDK\platform\hal\src\osc";".\SDK\platform\hal\src\port";".\SDK\platform\hal\src\rtc";".\SDK\platform\hal\src\sim\MKL27Z644";".\SDK\platform\hal\src\tpm";".\SDK\platform\hal\src\uart";".\SDK\platform\osa\src";".\SDK\platform\system\src\clock\MKL27Z644";".\SDK\platform\system\src\clock";".\SDK\platform\system\src\interrupt";".\SDK\platform\utilities\src";".\Sources";".\Static_Code\Peripherals";".\Static_Code\System";".\SDK\platform\devices\MKL27Z644\startup\arm"
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: .\Project_Settings\Linker_Files\ProcessorExpert.scf
  group GeneratedASMs
    ./SDK/platform/devices/MKL27Z644/startup/arm/: startup_MKL27Z644.s
  group GeneratedCs
    ./Generated_Code/: Cpu.c clockMan1.c hardware_init.c osa1.c pin_init.c tpmTmr1.c tpmTmr2.c tpmTmr3.c gpio4.c adConv1.c
    ./Sources/: Events.c main.c controllers_forgeneration.c controllers_forgeneration_data.c
    ./Static_Code/Peripherals/: GPIOA_Init.c GPIOB_Init.c
    ./Static_Code/System/: PE_low_level_init.c Peripherals_Init.c
    ./SDK/platform/system/src/clock/MKL27Z644/: fsl_clock_MKL27Z644.c
    ./SDK/platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ./SDK/platform/utilities/src/: fsl_debug_console.c fsl_misc_utilities.c print_scan.c
    ./SDK/platform/hal/src/gpio/: fsl_gpio_hal.c
    ./SDK/platform/system/src/interrupt/: fsl_interrupt_manager.c
    ./SDK/platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ./SDK/platform/hal/src/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal_modes.c
    ./SDK/platform/osa/src/: fsl_os_abstraction_bm.c
    ./SDK/platform/hal/src/osc/: fsl_osc_hal.c
    ./SDK/platform/hal/src/port/: fsl_port_hal.c
    ./SDK/platform/drivers/src/rtc/: fsl_rtc_common.c
    ./SDK/platform/hal/src/rtc/: fsl_rtc_hal.c
    ./SDK/platform/hal/src/sim/MKL27Z644/: fsl_sim_hal_MKL27Z644.c
    ./SDK/platform/hal/src/uart/: fsl_uart_hal.c
    ./SDK/platform/devices/: startup.c
    ./SDK/platform/devices/MKL27Z644/startup/: system_MKL27Z644.c
    ./SDK/platform/drivers/src/tpm/: fsl_tpm_common.c fsl_tpm_driver.c
    ./SDK/platform/hal/src/tpm/: fsl_tpm_hal.c
    ./SDK/platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ./SDK/platform/drivers/src/adc16/: fsl_adc16_common.c fsl_adc16_driver.c
    ./SDK/platform/hal/src/adc16/: fsl_adc16_hal.c
  group GeneratedHs
    ./Generated_Code/: Cpu.h GPIOA.h GPIOA_Config.h Init_Config.h PE_low_level_init.h board.h clockMan1.h osa1.h pin_init.h tpmTmr1.h GPIOB.h GPIOB_Config.h tpmTmr2.h tpmTmr3.h gpio4.h adConv1.h
    ./Sources/: Events.h controllers_forgeneration.h controllers_forgeneration_private.h controllers_forgeneration_types.h rtwtypes.h
    ./Static_Code/Peripherals/: GPIOA_Init.h GPIOB_Init.h
    ./SDK/platform/devices/MKL27Z644/include/: MKL27Z644.h MKL27Z644_extension.h MKL27Z644_features.h fsl_bitaccess.h
    ./Static_Code/System/: Peripherals_Init.h
    ./SDK/platform/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ./Static_Code/IO_Map/: core_cm0plus_PEx.h
    ./SDK/platform/system/src/clock/MKL27Z644/: fsl_clock_MKL27Z644.h
    ./SDK/platform/system/inc/: fsl_clock_manager.h fsl_interrupt_manager.h
    ./SDK/platform/utilities/inc/: fsl_debug_console.h fsl_misc_utilities.h
    ./SDK/platform/devices/: fsl_device_registers.h startup.h
    ./SDK/platform/hal/inc/: fsl_gpio_hal.h fsl_lpuart_hal.h fsl_mcglite_hal.h fsl_mcglite_hal_modes.h fsl_osc_hal.h fsl_port_hal.h fsl_rtc_hal.h fsl_sim_hal.h fsl_uart_hal.h fsl_tpm_hal.h fsl_adc16_hal.h
    ./SDK/platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_bm.h
    ./SDK/platform/hal/src/sim/MKL27Z644/: fsl_sim_hal_MKL27Z644.h
    ./SDK/platform/utilities/src/: print_scan.h
    ./Generated_Code/SDK/platform/devices/MKL27Z644/startup/: system_MKL27Z644.h
    ./SDK/platform/drivers/inc/: fsl_tpm_driver.h fsl_gpio_driver.h fsl_adc16_driver.h
